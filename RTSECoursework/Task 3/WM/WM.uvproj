# Keil uVision project WM.uvproj, settings and files
target WM (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) IRAM2(0x10000000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: WM
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xC,USE_STM32F3_DISCO,
  c misc: --C99
  c include: Inc;Drivers\STM32F3xx_HAL_Driver\Inc;Drivers\BSP\STM32F3-Discovery;Drivers\CMSIS\Device\ST\STM32F3xx\Include;Drivers\CMSIS\Include;StartUp\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Doc
    ./Docs/: direct IO access.txt project directories.txt
  group HAL
    ./Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc.c stm32f3xx_hal_spi.c stm32f3xx_hal_i2c.c
  group User
    ./Src/: main.cpp buttonpanel.cpp buzzer.cpp door.cpp motor.cpp ports.cpp processcontroller.cpp sevensegdisplay.cpp timer.cpp washingoperations.cpp
    ./Inc/: main.h ports.h classes.h
  group BSP
    Drivers/BSP/STM32F3-Discovery/: stm32f3_discovery.c
  group StartUp
    ./StartUp/Src/: stm32f3xx_it.c system_stm32f3xx.c startup_stm32f303xc.s board_startup.c
